options:
  parameters:
    generate_options: qt_gui
    id: multi_ue_scenario
    output_language: python
    title: srsRAN_multi_UE
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '11520000'
  states: {}
- name: slow_down_ratio
  id: variable_qtgui_range
  parameters:
    label: Time Slow Down Ratio
    rangeType: int
    start: '1'
    step: '1'
    stop: '15'
    value: '1'
    widget: counter
  states: {}
- name: ue1_delay
  id: variable_qtgui_range
  parameters:
    label: UE1 Delay
    rangeType: int
    start: '0'
    step: '1'
    stop: '4'
    value: '0'
    widget: counter
  states: {}
- name: ue1_noise
  id: variable_qtgui_range
  parameters:
    label: UE1 Noise [dB]
    start: '0'
    step: '0.2'
    stop: '1.8'
    value: '0'
    widget: counter
  states: {}
- name: ue1_path_loss_db
  id: variable_qtgui_range
  parameters:
    label: UE1 Pathloss [dB]
    rangeType: int
    start: '0'
    step: '10'
    stop: '100'
    value: '0'
    widget: counter
  states: {}
- name: ue2_delay
  id: variable_qtgui_range
  parameters:
    label: UE2 Delay
    rangeType: int
    start: '0'
    step: '1'
    stop: '4'
    value: '0'
    widget: counter
  states: {}
- name: ue2_noise
  id: variable_qtgui_range
  parameters:
    label: UE2 Noise [dB]
    start: '0'
    step: '0.2'
    stop: '1.8'
    value: '0'
    widget: counter
  states: {}
- name: ue2_path_loss_db
  id: variable_qtgui_range
  parameters:
    label: UE2 Pathloss [dB]
    rangeType: int
    start: '0'
    step: '10'
    stop: '100'
    value: '0'
    widget: counter
  states: {}
- name: ue3_delay
  id: variable_qtgui_range
  parameters:
    label: UE3 Delay
    rangeType: int
    start: '0'
    step: '1'
    stop: '4'
    value: '0'
    widget: counter
  states: {}
- name: ue3_noise
  id: variable_qtgui_range
  parameters:
    label: UE3 Noise [dB]
    start: '0'
    step: '0.2'
    stop: '1.8'
    value: '0'
    widget: counter
  states: {}
- name: ue3_path_loss_db
  id: variable_qtgui_range
  parameters:
    label: UE3 Pathloss [dB]
    rangeType: int
    start: '0'
    step: '10'
    stop: '100'
    value: '0'
    widget: counter
  states: {}
- name: zmq_hwm
  id: variable
  parameters:
    value: '-1'
  states: {}
- name: zmq_timeout
  id: variable
  parameters:
    value: '100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 1*ue1_delay
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: 1*ue1_delay
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: 1*ue2_delay
    type: complex
  states: {}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: 1*ue2_delay
    type: complex
  states: {}
- name: blocks_delay_2
  id: blocks_delay
  parameters:
    delay: 1*ue3_delay
    type: complex
  states: {}
- name: blocks_delay_2_0
  id: blocks_delay
  parameters:
    delay: 1*ue3_delay
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue1_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue2_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue3_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue1_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue3_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(-1.0*ue2_path_loss_db/20.0)
    type: complex
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: 1.0*samp_rate/(1.0*slow_down_ratio)
    type: complex
  states: {}
- name: channels_phase_noise_gen_0
  id: channels_phase_noise_gen
  parameters:
    alpha: '0.1'
    noise_mag: 1*ue1_noise
  states: {}
- name: channels_phase_noise_gen_0_0
  id: channels_phase_noise_gen
  parameters:
    alpha: '0.1'
    noise_mag: 1*ue1_noise
  states: {}
- name: channels_phase_noise_gen_0_1
  id: channels_phase_noise_gen
  parameters:
    alpha: '0.1'
    noise_mag: 1*ue2_noise
  states: {}
- name: channels_phase_noise_gen_0_1_0
  id: channels_phase_noise_gen
  parameters:
    alpha: '0.1'
    noise_mag: 1*ue3_noise
  states: {}
- name: channels_phase_noise_gen_0_1_0_0
  id: channels_phase_noise_gen
  parameters:
    alpha: '0.1'
    noise_mag: 1*ue3_noise
  states: {}
- name: channels_phase_noise_gen_0_1_1
  id: channels_phase_noise_gen
  parameters:
    alpha: '0.1'
    noise_mag: 1*ue2_noise
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2100
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2200
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2001
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_rep_sink_0_2
  id: zeromq_rep_sink
  parameters:
    address: tcp://127.0.0.1:2300
    hwm: zmq_hwm
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2000
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_0_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2301
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2101
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}
- name: zeromq_req_source_1_0
  id: zeromq_req_source
  parameters:
    address: tcp://127.0.0.1:2201
    hwm: zmq_hwm
    timeout: zmq_timeout
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', zeromq_rep_sink_0_1, '0']
- [blocks_delay_0, '0', channels_phase_noise_gen_0, '0']
- [blocks_delay_0_0, '0', channels_phase_noise_gen_0_0, '0']
- [blocks_delay_1, '0', channels_phase_noise_gen_0_1, '0']
- [blocks_delay_1_0, '0', channels_phase_noise_gen_0_1_1, '0']
- [blocks_delay_2, '0', channels_phase_noise_gen_0_1_0, '0']
- [blocks_delay_2_0, '0', channels_phase_noise_gen_0_1_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_delay_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_delay_1_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_delay_2_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_delay_2, '0']
- [blocks_multiply_const_vxx_0_1_1, '0', blocks_delay_1, '0']
- [blocks_throttle_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_throttle_0_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_throttle_0_0, '0', blocks_multiply_const_vxx_0_1_1, '0']
- [channels_phase_noise_gen_0, '0', zeromq_rep_sink_0, '0']
- [channels_phase_noise_gen_0_0, '0', blocks_add_xx_0, '0']
- [channels_phase_noise_gen_0_1, '0', zeromq_rep_sink_0_0, '0']
- [channels_phase_noise_gen_0_1_0, '0', zeromq_rep_sink_0_2, '0']
- [channels_phase_noise_gen_0_1_0_0, '0', blocks_add_xx_0, '2']
- [channels_phase_noise_gen_0_1_1, '0', blocks_add_xx_0, '1']
- [zeromq_req_source_0, '0', blocks_throttle_0_0, '0']
- [zeromq_req_source_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [zeromq_req_source_1, '0', blocks_multiply_const_vxx_0, '0']
- [zeromq_req_source_1_0, '0', blocks_multiply_const_vxx_0_0, '0']

metadata:
  file_format: 1
